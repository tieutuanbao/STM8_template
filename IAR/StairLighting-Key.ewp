# IAR project StairLighting-Key.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: ..\core\include; ..\source\hw\include; ..\source\led_control; ..\source\serial
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: StairLighting-Key.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ../source/: main.c
  group core
    ../core/source/: stm8s_clk.c stm8s_gpio.c stm8s_tim4.c stm8s_uart1.c
  group devices
    ../source/led_control/: led_control.c
    ../source/serial/: serial.c
